# Keil uVision project swd_downloader.uvprojx, settings and files
target Offline_downloader (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: OFDD +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  AfterMake: fromelf --text -a -c -o "$L@L.asm" "#L"
  c flags: Optim=2 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_MD USE_STDPERIPH_DRIVER
  c misc: --c99
  c include: .\src;.\src\DAP;.\src\CSL;.\src\CSL\CMSIS\CoreSupport;.\src\CSL\CMSIS\DeviceSupport;.\src\CSL\STM32F10x_StdPeriph_Driver;.\src\CSL\STM32_USB-FS-Device_Driver
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./src/: main.c SWD_host.c SWD_flash.c
  group DAP
    ./src/DAP/: DAP.c SW_DP.c
  group CMSIS
    ./src/CSL/CMSIS/DeviceSupport/: system_stm32f10x.c
    ./src/CSL/CMSIS/DeviceSupport/startup/arm/: startup_stm32f10x_md.s startup_stm32f10x_hd.s
  group StdPD
    ./src/CSL/STM32F10x_StdPeriph_Driver/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c
